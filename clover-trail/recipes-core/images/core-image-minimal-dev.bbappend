IMAGE_FSTYPES += "squashfs"
