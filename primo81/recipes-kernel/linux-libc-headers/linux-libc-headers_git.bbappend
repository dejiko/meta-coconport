FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# uses linux 4.13-rc6
KERNGIT_VERSION = "4.13.0"
KERNGIT_SRCREV = "14ccee78fc82f5512908f4424f541549a5705b89"
KERNGIT = "${KERNGIT_VERSION}+gitAUTOINC+%"
